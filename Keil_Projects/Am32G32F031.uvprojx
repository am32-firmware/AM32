# Keil uVision project Am32G32F031.uvprojx, settings and files
target AM32REF_G32F031 (6220000::V6.22::ARMCLANG)
  device: G32F031K8 Geehy
  pack: Geehy.G32F031_DFP.0.3.3
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AM32REF_G32F031 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: G32F031xx,USE_FULL_DDL_DRIVER, GEEHY_G32F031
  c include: ..\Mcu\g32f031\Drivers\CMSIS\Include;..\Mcu\g32f031\Drivers\CMSIS\Device\Geehy\G32F0xx\Include;..\Mcu\g32f031\Drivers\G32F031_DAL_Driver\Inc;..\Mcu\g32f031\Inc;..\inc
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: ..\Mcu\g32f031\Am32 64kb_g32f031.sct
  group startup
    ../Mcu/g32f031/Startup/: system_g32f031.c
    ../Mcu/g32f031/Startup/mdk/: startup_g32f031.s
  group Src
    ../Src/: dshot.c functions.c main.c signal.c sounds.c firmwareversion.c kiss_telemetry.c
  group f031
    ../Inc/: targets.h
    ../Mcu/g32f031/Src/: ADC.c comparator.c eeprom.c g32f031_int.c IO.c peripherals.c phaseouts.c serial_telemetry.c
  group Drivers/G32F031_DAL_Driver
    ../Mcu/g32f031/Drivers/G32F031_DAL_Driver/Src/: g32f031_ddl_utils.c g32f031_ddl_adc.c g32f031_ddl_atmr.c g32f031_ddl_btmr.c g32f031_ddl_comp0.c g32f031_ddl_comp1.c g32f031_ddl_crc.c g32f031_ddl_div.c g32f031_ddl_dma.c g32f031_ddl_eint.c g32f031_ddl_flash.c g32f031_ddl_gpio.c g32f031_ddl_gtmr.c g32f031_ddl_i2c.c g32f031_ddl_lptmr.c g32f031_ddl_opa.c g32f031_ddl_rcc.c g32f031_ddl_spi.c g32f031_ddl_uart.c g32f031_ddl_usart.c
